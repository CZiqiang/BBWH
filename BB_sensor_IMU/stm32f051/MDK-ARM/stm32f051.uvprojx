# Keil uVision project stm32f051.uvprojx, settings and files
target stm32f051 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F051K8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: stm32f051 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F051x8
  c include: ../Core/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;..\..\IMU\utilites;..\..\IMU\drivers;..\..\IMU\drivers\icm426xx;..\..\IMU\algorithm\src;..\..\IMU\algorithm\inc;..\..\IMU\app;..\..\IMU\utilites\anoupper;..\..\reference\libfixmath-master\libfixmath;D:\Keil_v5\ARM\ARMCC\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: stm32f051\stm32f051.sct
  link misc: --libpath "D:\Keil_V5\ARM\ARMCC\lib"
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c spi.c usart.c stm32f0xx_it.c stm32f0xx_hal_msp.c private_debug.c
  group Application/User/Driver
    ../../IMU/drivers/icm426xx/: ICM42605.c icm42605SelfTest.c
    ../../IMU/utilites/: bbsensor_utilites.c
    ../../IMU/app/: inv_app.c
    ../../IMU/utilites/anoupper/: ano_bbuf.c
    ../../reference/libfixmath-master/libfixmath/: fix16.c
  group Application/User/Headerfiles
    ../Core/Inc/: dma.h gpio.h i2c.h main.h spi.h stm32f0xx_hal_conf.h stm32f0xx_it.h usart.h
    ../../IMU/app/: inv_app.h
    ../../IMU/drivers/icm426xx/: icm426xxDefs.h ICM42605.h icm42605SelfTest.h
    ../../IMU/utilites/: bbsensor_utilites.h
  group Application/MDK-ARM
    ./: startup_stm32f051x8.s
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
software components: CMSIS:CORE 4.3.0
